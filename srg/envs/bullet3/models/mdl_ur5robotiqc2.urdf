Commit message: wip...

File: srg/envs/bullet3/models/mdl_ur5robotiqc2.urdf (robot description, URDF)
Before this commit: robot sisbot, 19 links, 18 joints
Joints:
- joint world_joint: origin xyz=0.0 0.0 0.1 rpy=0.0 0.0 0 -> xyz=0.0 0.0 0.0 rpy=0.0 0.0 0
